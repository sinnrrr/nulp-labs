# Keil uVision project lab11_test.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: prjFinal +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\STM32F401-Discovery_FW_V1.0.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\src;.\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group CGroup
    ./src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_gpio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
